v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -0 -60 -0 -30 {lab=C1}
N 0 30 -0 70 {lab=BOT}
C {cap_mim_m3_1.sym} 0 0 0 0 {name=C1 model=cap_mim_m3_1 W=18.3147 L=18.3147 MF=1 spiceprefix=X}
C {iopin.sym} 0 -50 0 0 {name=p1 lab=C1}
C {iopin.sym} 0 60 0 0 {name=p2 lab=C2
}
