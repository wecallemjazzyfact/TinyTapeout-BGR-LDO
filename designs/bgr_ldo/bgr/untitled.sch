v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {vsource.sym} 0 -30 0 0 {name=Vref value=1.2 savecurrent=false}
